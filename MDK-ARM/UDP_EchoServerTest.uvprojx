# Keil uVision project UDP_EchoServerTest.uvprojx, settings and files
target UDP_EchoServerTest (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: UDP_EchoServerTest
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: mppe.c multilink.c demand.c vj.c ipcp.c fsm.c pppos.c eui64.c chap-md5.c chap_ms.c pppol2tp.c ecp.c chap-new.c lcp.c eap.c pppcrypt.c pppoe.c upap.c ccp.c utils.c ppp.c pppapi.c magic.c auth.c ipv6cp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_addr.c ip6_frag.c mld6.c ethip6.c dhcp6.c nd6.c icmp6.c ip6.c inet6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c ip4.c igmp.c etharp.c autoip.c ip4_addr.c icmp.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/: memp.c sys.c inet_chksum.c stats.c def.c ip.c dns.c raw.c tcp_out.c netif.c udp.c mem.c tcp.c tcp_in.c init.c timeouts.c pbuf.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md5.c md4.c des.c sha1.c arc4.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_msg.c tcpip.c api_lib.c sockets.c netifapi.c err.c netdb.c netbuf.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c lwip.c stm32f4xx_it.c ethernetif.c udp_echoserver.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rtc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c
software components: CMSIS:CORE 4.1.0
